Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 801.ifc
Time: 2025-03-14T08:42:18
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 101
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (20)
In: UnknownName
Properties - Area: 60; IsNull: no; NumChanges: 2; RecordHistory: yes; ShowHistory: yes; UsesGraphicsCache: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: yes; IsModifiedGraphics: yes; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 801; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Odhumusování; Skupina elementů: zemní práce; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_Z1 - Skupina přesnosti: P100
CZ_M3 - Způsob stanovení objemu: objemová metoda
CZ_F1 - Fáze: trvalý stav
Name | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Označení položky | Označení šablony vlastností | Klasifikace zemin / hornin = Další specifikace | Třída těžitelnosti | Textura / barva | Objem
zemní práce-sejmutí ornice | ((-642925.949788904,-1062678.12363751,233),(-642920.949788904,-1062673.12363751,233.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 624.66 | 631.18 | sejmutí ornice | 121102 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 1810
zemní práce-sejmutí ornice | ((-642821.783259094,-1062690.36817099,233),(-642816.783259094,-1062685.36817099,233.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 729.5 | 737.06 | sejmutí ornice | 12110 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 627
zemní práce-sejmutí ornice | ((-642684.171492483,-1062703.34707673,232),(-642679.171492483,-1062698.34707673,232.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 833.78 | 841.67 | sejmutí ornice | 121102 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 397
zemní práce-rozprostření ornice (ohumusovani) | ((-641965.084014665,-1063193.26829626,232),(-641960.084014665,-1063188.26829626,232.5)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 1724.28 | 1730.93 | rozprostření ornice (ohumusovani) | 12573 | I1+S1+E1+Z1+M3;2&6+F1 |  |  | 165;207;99 | 1592 | CZ_S1 - Materiál: podornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | ((-641257.563428089,-1063523.02392397,235),(-641252.563428089,-1063518.02392397,235.5)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 2504.87 | 2511.52 | rozprostření ornice (ohumusovani) | 12573 | I1+S1+E1+Z1+M3;2&6+F1 |  |  | 165;207;99 | 200 | CZ_S1 - Materiál: podornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-sejmutí ornice | ((-641267.135514409,-1063519.23965872,235),(-641262.135514409,-1063514.23965872,235.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 2494.6 | 2501.24 | sejmutí ornice | 121101 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 230
zemní práce-rozprostření ornice (ohumusovani) | ((-640813.69452129,-1063721.38686502,240),(-640808.69452129,-1063716.38686502,240.5)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 2990.97 | 2997.62 | rozprostření ornice (ohumusovani) | 12573 | I1+S1+E1+Z1+M3;2&6+F1 |  |  | 165;207;99 | 983 | CZ_S1 - Materiál: podornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-sejmutí ornice | ((-640823.26660761,-1063717.60259978,240),(-640818.26660761,-1063712.60259978,240.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 2980.7 | 2987.35 | sejmutí ornice | 121102 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 962
zemní práce-sejmutí ornice | ((-640673.993667931,-1063787.56030053,234),(-640668.993667931,-1063782.56030053,234.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 3145.46 | 3151.6 | sejmutí ornice | 121102 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 1926
zemní práce-sejmutí ornice | ((-640256.68246252,-1063765.41922653,230),(-640251.68246252,-1063760.41922653,230.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 3570.25 | 3576.65 | sejmutí ornice | 121106 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 2000
zemní práce-rozprostření ornice (ohumusovani) | ((-639819.780486356,-1063609.41757541,229),(-639814.780486356,-1063604.41757541,229.5)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 4034.35 | 4040.81 | rozprostření ornice (ohumusovani) | 18232 | I1+S1+E1+Z1+M3;2&6+F1 |  |  | 165;207;99 | 2529 | CZ_S1 - Materiál: ornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | ((-639808.650268827,-1063606.88973619,229),(-639803.650268827,-1063601.88973619,229.5)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 4045.71 | 4052.16 | rozprostření ornice (ohumusovani) | 12573 | I1+S1+E1+Z1+M3;2&6+F1 |  |  | 165;207;99 | 1828 | CZ_S1 - Materiál: podornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | ((-639596.372259168,-1063543.33905876,230),(-639591.372259168,-1063538.33905876,230.5)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 4268.62 | 4274.59 | rozprostření ornice (ohumusovani) | 18232 | I1+S1+E1+Z1+M3;2&6+F1 |  |  | 165;207;99 | 4908 | CZ_S1 - Materiál: ornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | ((-639585.242041639,-1063540.81121954,230),(-639580.242041639,-1063535.81121954,230.5)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 4280.09 | 4286.03 | rozprostření ornice (ohumusovani) | 12573 | I1+S1+E1+Z1+M3;2&6+F1 |  |  | 165;207;99 | 1440 | CZ_S1 - Materiál: podornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-sejmutí ornice | ((-639387.637640902,-1063500.11187343,230),(-639382.637640902,-1063495.11187343,230.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 4481.88 | 4487.26 | sejmutí ornice | 12573 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 2245
zemní práce-rozprostření ornice (ohumusovani) | ((-639376.507423373,-1063497.58403421,230),(-639371.507423373,-1063492.58403421,230.5)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 4493.15 | 4498.48 | rozprostření ornice (ohumusovani) | 12573 | I1+S1+E1+Z1+M3;2&6+F1 |  |  | 165;207;99 | 2051 | CZ_S1 - Materiál: podornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-sejmutí ornice | ((-640251.450338809,-1063756.99329349,230),(-640246.450338809,-1063751.99329349,230.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 3578 | 3584.46 | sejmutí ornice | 18232 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | 1 | 125;75;0 | 6866 | CZ_S1 - Materiál: ornice; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.6.1.2; CZ_M6 - Tloušťka: 0.15
zemní práce-sejmutí ornice | ((-639176.202020391,-1063490.67096925,230),(-639171.202020391,-1063485.67096925,230.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 4692.48 | 4697.69 | sejmutí ornice | 121101 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 1410
zemní práce-sejmutí ornice | ((-639108.766747522,-1063513.00814993,230),(-639103.766747522,-1063508.00814993,230.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 4761.07 | 4766.53 | sejmutí ornice | 121101 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 642
zemní práce-sejmutí ornice | ((-641309.038382193,-1063365.15599086,233),(-641304.038382193,-1063360.15599086,233.5)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 2391.36 | 2398 | sejmutí ornice | 12110 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | 125;75;0 | 7957
