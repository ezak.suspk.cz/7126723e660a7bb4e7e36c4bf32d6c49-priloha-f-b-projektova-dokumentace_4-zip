Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 802.ifc
Time: 2025-03-14T08:42:48
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 802
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Zakázka: přeložka silnice II/322 Černá za Bory - Dašice; Stupeň PD: PDPS; Název výkresu: SITUACE; Příloha č.: 2; Část: D.6.2; Datum PD: 10.2024; Místo: Pardubický kraj/ Pardubice - Dašice; Souřadnicový systém: S-JTSK; Výškový systém: Bpv

# IfcAnnotation: Breakline (36)
In: UnknownName
PredefinedType: USERDEFINED
Breakline Properties - BreaklineType: Standard; MidOrdinateDistance: 1 m
Name | Description
20 x  | Nastavit povinnou spojnici 1
14 x  | Nastavit povinnou spojnici 2
2 x  | Nastavit povinnou spojnici 3

# IfcBuiltElement (10)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; NumChanges: 1; RecordHistory: no; ShowHistory: no; UsesGraphicsCache: yes; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes; ColorIndex: 40; Layer: propustky-zásypy a obsypy; PlotStyleName: Barva_40
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 802; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Oplocení silnice; Klasifikační systém: OTSKP; Označení elementu: zásypy a obsypy; Skupina elementů: propustky; Označení položky: 45152; Označení šablony vlastností: I1+S1;3+E1+Z1+M3+F1
CZ_S1 - Reference: D.6.2.2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Materiál: štěrk fr. 16/32
CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_Z1 - Textura / barva: 255;165;0; Skupina přesnosti: P50
CZ_M3 - Způsob stanovení objemu: řezová metoda
CZ_F1 - Fáze: trvalý stav
Name | Area | Bounds | Staničení od | Staničení do | Objem
propustky-zásypy a obsypy | 547.139 | ((-640048.553525685,-1063673.85623339,228.946097664606),(-639748.418424938,-1063558.39483717,230.342036500417)) | 3798.01 | 4118.29 | 33.7536
propustky-zásypy a obsypy | 546.766 | ((-640053.929835434,-1063711.90028967,229.049049233215),(-639753.492084171,-1063596.68183627,230.565023653636)) | 3779.09 | 4101.4 | 33.7493
2 x propustky-zásypy a obsypy | 41.6011 | ((-640074.873363989,-1063684.57097632,229.548197309864),(-640052.058707146,-1063674.82444739,230.235266266811)) | 3769.59 | 3793.92 | 2.55344
propustky-zásypy a obsypy | 921.912 | ((-640612.767502361,-1063788.22218232,228.737595232805),(-640087.146317253,-1063688.72894584,232.560906129286)) | 3204.41 | 3756.18 | 56.8973
propustky-zásypy a obsypy | 867.779 | ((-640560.707780828,-1063828.19177091,229.762436733594),(-640071.697442917,-1063718.91237597,231.60332567477)) | 3262.43 | 3757.69 | 53.5803
propustky-zásypy a obsypy | 93.9011 | ((-640619.315503019,-1063820.43249715,231.528962869793),(-640565.567233824,-1063808.40177121,232.494580084902)) | 3204.08 | 3257.57 | 5.78615
propustky-zásypy a obsypy | 27.6604 | ((-640644.828233034,-1063818.54275016,232.899811269262),(-640638.389802245,-1063803.21761013,233.147275610717)) | 3181.89 | 3184.69 | 1.69535
propustky-zásypy a obsypy | 1208.7 | ((-641281.260272412,-1063775.45351147,233.073295531302),(-640631.814084238,-1063491.82499418,242.495111107094)) | 2472.56 | 3184.64 | 74.6033
propustky-zásypy a obsypy | 2823.61 | ((-642737.587017538,-1063490.39238767,229.978665364684),(-641285.72430895,-1062737.79063682,234.227269575493)) | 834.11 | 2467.4 | 174.284

# IfcGeographicElement (18)
In: UnknownName
Description: Popis; PredefinedType: TERRAIN
Properties - AutoRebuild: no; HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; Description: Popis; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; IsUsed: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 802; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Oplocení silnice; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | FingerPrint | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Textura / barva | Skupina přesnosti
ostatní-oplocení-1 | -1423857266 | ostatní-oplocení-1 | postřiky | ((-642837.127501794,-1063590.0808536,229.978665364684),(-641185.864500049,-1062637.9814339,235.877269575493)) | 4 | ostatní-oplocení | Barva_4 | 836.37 | 2467.39 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 1660; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-2 | -2025134321 | ostatní-oplocení-2 | postřiky | ((-641381.124086773,-1063875.17665726,233.073295531302),(-640532.017250969,-1063392.14569101,244.145111107094)) | 4 | ostatní-oplocení | Barva_4 | 2500 | 3181.03 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 681.03; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-3 | -779222663 | ostatní-oplocení-3 | postřiky | ((-640744.510804442,-1063918.41735155,232.899811269262),(-640538.716566973,-1063703.33942592,234.797275610717)) | 4 | ostatní-oplocení | Barva_4 | 3182.21 | 3184.35 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 16; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-4 | -869088224 | ostatní-oplocení-4 | postřiky | ((-640712.560058591,-1063887.88210774,228.737595232805),(-639987.266606147,-1063589.05630943,234.210906129286)) | 4 | ostatní-oplocení | Barva_4 | 3204.67 | 3724.44 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 542; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-5 | 1105321562 | ostatní-oplocení-5 | postřiky | ((-640719.141584804,-1063920.09600104,231.528962869793),(-640465.6173522,-1063708.70251532,234.144580084902)) | 4 | ostatní-oplocení | Barva_4 | 3204.19 | 3257.56 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 55; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-6 | -67091212 | ostatní-oplocení-6 | postřiky | ((-640660.664301067,-1063927.85176205,229.762436733594),(-639972.022617786,-1063619.3670163,233.25332567477)) | 4 | ostatní-oplocení | Barva_4 | 3262.44 | 3751.96 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 510; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-7 | -805841389 | ostatní-oplocení-7 | postřiky | ((-640153.805212864,-1063811.5825728,229.049049233215),(-639653.682059183,-1063496.97210391,232.215023653636)) | 4 | ostatní-oplocení | Barva_4 | 3779.09 | 4100.42 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 321; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-8 | -1275891576 | ostatní-oplocení-8 | postřiky | ((-640174.742431909,-1063784.25566313,229.548197309864),(-639952.18589831,-1063575.14903449,231.885266266811)) | 4 | ostatní-oplocení | Barva_4 | 3769.6 | 3786.01 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 25; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-9 | 697870240 | ostatní-oplocení-9 | postřiky | ((-640148.426207319,-1063773.53952676,228.946097664606),(-639648.422593317,-1063458.74556461,231.992036500417)) | 4 | ostatní-oplocení | Barva_4 | 3798.01 | 4108.91 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.2.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 321; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
vozovka_chodník-geosyntetikum-1 | 637701407 | vozovka_chodník-geosyntetikum-1 | geotextilie | ((-642837.587017538,-1063590.39238767,229.978665364684),(-641185.72430895,-1062637.79063682,234.077269575493)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 836.02 | 2467.4 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 1162.72; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-2 | 1958888089 | vozovka_chodník-geosyntetikum-2 | geotextilie | ((-641381.260272412,-1063875.45351147,233.073295531302),(-640531.814084238,-1063391.82499418,242.345111107094)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 2500 | 3180.9 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 497.67; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-3 | 1229412145 | vozovka_chodník-geosyntetikum-3 | geotextilie | ((-640744.828233034,-1063918.54275016,232.899811269262),(-640538.389802245,-1063703.21761013,232.997275610717)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 3181.89 | 3184.69 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 11.3033; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-4 | -1740313843 | vozovka_chodník-geosyntetikum-4 | geotextilie | ((-640719.315503019,-1063920.43249715,231.528962869793),(-640465.567233824,-1063708.40177121,232.344580084902)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 3204.08 | 3257.57 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 38.5796; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-5 | 1480395024 | vozovka_chodník-geosyntetikum-5 | geotextilie | ((-640660.707780828,-1063928.19177091,229.762436733594),(-639971.697442917,-1063618.91237597,231.45332567477)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 3262.43 | 3751.96 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 357.241; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-6 | -1088013587 | vozovka_chodník-geosyntetikum-6 | geotextilie | ((-640712.767502361,-1063888.22218232,228.737595232805),(-639987.146317253,-1063588.72894584,232.410906129286)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 3204.41 | 3745.47 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 379.569; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-7 | 762460801 | vozovka_chodník-geosyntetikum-7 | geotextilie | ((-640174.873363989,-1063784.57097632,229.548197309864),(-639952.058707146,-1063574.82444739,230.085266266811)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 3769.6 | 3786.02 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 17.0478; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-8 | 145807620 | vozovka_chodník-geosyntetikum-8 | geotextilie | ((-640148.553525685,-1063773.85623339,228.946097664606),(-639648.418424938,-1063458.39483717,230.192036500417)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 3798.01 | 4108.92 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 225.245; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-9 | -221823704 | vozovka_chodník-geosyntetikum-9 | geotextilie | ((-640153.929835434,-1063811.90028967,229.049049233215),(-639653.492084171,-1063496.68183627,230.415023653636)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 3779.09 | 4100.52 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.2.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 225.065; Způsob stanovení plochy: 3D plocha TIN povrchu
