Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 803.ifc
Time: 2025-03-14T08:45:04
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 803
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Zakázka: přeložka silnice II/322 Černá za Bory - Dašice; Stupeň PD: PDPS; Název výkresu: SITUACE; Příloha č.: 2; Část: D.6.2; Datum PD: 10.2024; Místo: Pardubický kraj/ Pardubice - Dašice; Souřadnicový systém: S-JTSK; Výškový systém: Bpv

# IfcAnnotation: Breakline (8)
In: UnknownName
PredefinedType: USERDEFINED
Breakline Properties - BreaklineType: Standard; MidOrdinateDistance: 1 m
Name | Description
6 x  | Nastavit povinnou spojnici 2
2 x  | Nastavit povinnou spojnici 3

# IfcBuiltElement (11)
In: UnknownName
Properties - HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
Name | ForceAnnoAllVisible | Bounds | ColorIndex | Layer | PlotStyleName | ArrowSize | BlockRotation = Scale | DoglegLength = TextHeight | EnableAnnotationScale = EnableDogleg = EnableLanding = ExtendLeaderToText | EnableFrameText | LandingGap = LeaderCount = LeaderLineCount
propustky-zásypy a obsypy | yes | ((-642882.748486662,-1063233.94255377,230.115872473727),(-641960.029350389,-1062788.3505536,232.556088156109)) | 40 | propustky-zásypy a obsypy | Barva_40 | Properties - Area: 1779.97; IsNull: no; NumChanges: 1; RecordHistory: no; ShowHistory: no; UsesGraphicsCache: yes; CZ_I1 - Označení stavebního objektu: SO 803; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Oplocení železnice; Klasifikační systém: OTSKP; Staničení od: 715.27; Staničení do: 1747.95; Označení elementu: zásypy a obsypy; Skupina elementů: propustky; Označení položky: 45152; Označení šablony vlastností: I1+S1;3+E1+Z1+M3+F1; CZ_S1 - Reference: D.6.3.2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Materiál: štěrk fr. 16/32; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni; CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni; CZ_Z1 - Textura / barva: 255;165;0; Skupina přesnosti: P50; CZ_M3 - Objem: 109.835; Způsob stanovení objemu: řezová metoda; CZ_F1 - Fáze: trvalý stav
propustky-zásypy a obsypy | yes | ((-641303.872406357,-1063849.68937898,231.995799999954),(-640651.096339835,-1063539.1120036,243.332535551542)) | 40 | propustky-zásypy a obsypy | Barva_40 | Properties - Area: 1277.5; IsNull: no; NumChanges: 1; RecordHistory: no; ShowHistory: no; UsesGraphicsCache: yes; CZ_I1 - Označení stavebního objektu: SO 803; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Oplocení železnice; Klasifikační systém: OTSKP; Staničení od: 2472.11; Staničení do: 3182.77; Označení elementu: zásypy a obsypy; Skupina elementů: propustky; Označení položky: 45152; Označení šablony vlastností: I1+S1;3+E1+Z1+M3+F1; CZ_S1 - Reference: D.6.3.2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Materiál: štěrk fr. 16/32; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni; CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni; CZ_Z1 - Textura / barva: 255;165;0; Skupina přesnosti: P50; CZ_M3 - Objem: 78.8202; Způsob stanovení objemu: řezová metoda; CZ_F1 - Fáze: trvalý stav
 | no | ((-642706.305454121,-1062926.34527844,0),(-642623.164529783,-1062868.68629838,0)) | 256 | ms_popisky | ByLayer | 2 | 0 | 2 | yes | no | 1
 | no | ((-642884.849994741,-1062855.51999451,0),(-642785.131317768,-1062810.51980984,0)) | 256 | ms_popisky | ByLayer | 2 | 0 | 2 | yes | no | 1
 | no | ((-642063.973348213,-1063237.4877223,0),(-641980.832423875,-1063179.82874224,0)) | 256 | ms_popisky | ByLayer | 2 | 0 | 2 | yes | no | 1
 | no | ((-641179.198004055,-1063656.52149739,0),(-641088.600869096,-1063615.00869264,0)) | 256 | ms_popisky | ByLayer | 2 | 0 | 2 | yes | no | 1
 | no | ((-640756.874686981,-1063854.91625172,0),(-640667.718387481,-1063798.8957873,0)) | 256 | ms_popisky | ByLayer | 2 | 0 | 2 | yes | no | 1
 | no | ((-640735.553424366,-1063852.43223374,0),(-640648.207766255,-1063771.82538318,0)) | 256 | ms_popisky | ByLayer | 3 | 0 | 2 | yes | no | 1
 | no | ((-641382.030103003,-1063553.13959017,0),(-641305.482258732,-1063517.36825999,0)) | 256 | ms_popisky | ByLayer | 2 | 0 | 2 | yes | no | 1
 | no | ((-642892.043533408,-1062880.86128593,0),(-642754.833212049,-1062820.36752637,0)) | 256 | ms_popisky | ByLayer | 4 | 0 | 2 | yes | no | 1
 | no | ((-642549.501321721,-1063044.22629503,0),(-642412.291000361,-1062989.80281587,0)) | 256 | ms_popisky | ByLayer | 4 | 0 | 2 | yes | no | 1

# IfcGeographicElement (4)
In: UnknownName
Description: Popis; PredefinedType: TERRAIN
Properties - AutoRebuild: no; HasSnapshot: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; Description: Popis; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; IsUsed: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 803; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Oplocení železnice; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | IsOutOfDate | FingerPrint | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Textura / barva | Skupina přesnosti
ostatní-oplocení-1 | yes | -204619376 | ostatní-oplocení-1 | postřiky | ((-642982.439099619,-1063333.6322576,230.115872473727),(-641860.186638715,-1062688.81309148,234.206088156109)) | 4 | ostatní-oplocení | Barva_4 | 715.52 | 1736.88 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.3.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 1046; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
ostatní-oplocení-2 | yes | 74707629 | ostatní-oplocení-2 | postřiky | ((-641403.733167201,-1063949.38,231.995799999954),(-640551.255323995,-1063439.42394028,244.982535551542)) | 4 | ostatní-oplocení | Barva_4 | 2484.25 | 3178.93 | oplocení | ostatní | 767912 | I1+S2+E1+Z1+M1;5+F1 | 0;255;255 | P10 | CZ_S2 - Typ stavebního výrobku: oplocení; Stavební výrobek: v. 1,8 m; Specifikace: pletivo pozinkované vysokopevnostní; Podrobná specifikace: nerelevantni; Reference: D.6.3.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 750; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
vozovka_chodník-geosyntetikum-1 | no | -139829621 | vozovka_chodník-geosyntetikum-1 | geotextilie | ((-642982.748486662,-1063333.94255377,230.115872473727),(-641860.029350389,-1062688.3505536,232.406088156109)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 715.78 | 1736.86 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.3.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 732.978; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum-2 | no | 46220434 | vozovka_chodník-geosyntetikum-2 | geotextilie | ((-641403.872406357,-1063949.68937898,231.995799999954),(-640551.096339835,-1063439.1120036,243.182535551542)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 2484.07 | 3175.49 | geosyntetikum | vozovka/chodník | 289971 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Reference: D.6.3.2; Materiál: netkaná geotextilie min. 50 g/m2; specifikace: nerelevantni; podrobná specifikace: nerelevantni; CZ_M2 - Plocha: 526.07; Způsob stanovení plochy: 3D plocha TIN povrchu
