Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture], Option [ExcludedObjects: BlockReference, CurtainWallLayout, Door, WindowAssembly, EntRef, MassElem, MassGroup, MvBlockRef, Railing, Roof, RoofSlab, Slab, , Space, Stair, Member, Wall, Window, Zone, ColumnGrid, AeccDbAlignment]
Time: 2025-07-10T09:33:08
Author: SobrM
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: Autodesk Civil 3D 2023 - Čeština (Czech) Build 13.5.131.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 10 09:33:08 2025 * Host: SOBRM_NB * Database: C:\Users\sobrm\AppData\Local\Temp\ACAIFCTMP/EDM10412\aec_ifc_db * Database version: 5507 * Database creation date: Thu Jul 10 09:07:33 2025 * Schema: IFC4 * Model: DataRepository.AecIfc * Model creation date: Thu Jul 10 09:32:29 2025 * Header model: DataRepository.AecIfc_Header * Header model creation date: Thu Jul 10 09:32:29 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 01
LongName: 3D_1
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, 3D_1
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingElementProxy (875)
In: 3D_1
CZ_I1 - Fáze projektu: DUR
CZ_E1 - Datum uvedení do provozu: 29.04.2025
CZ_Z1 - Skupina přesnosti: PX
Name | Označení stavebního objektu | Označení podobjektu = Označení části objektu = Klasifikační systém = Označení položky = Označení šablony vlastností = Stavební postup / etapa výstavby | Název stavebního objektu | Staničení od | Staničení do | Označení elementu | Skupina elementů | Klasifikace zemin / hornin = Třída těžitelnosti = Další specifikace | Datum zahájení prací | Datum dokončení | Doba trvání | Textura / barva | Objem | Způsob stanovení objemu
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0 | 0.0095 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 45.171 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0095 | 0.00975 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.23713 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00975 | 0.01 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.22625 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01 | 0.01 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.0239031 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01 | 0.01025 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.18922 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01025 | 0.0105 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.20007 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0105 | 0.01075 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.18709 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01075 | 0.011 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.17496 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.011 | 0.01123 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.08196 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01123 | 0.01125 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.0818244 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01125 | 0.0115 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.14069 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0115 | 0.01175 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.13507 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01175 | 0.012 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.12996 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.012 | 0.01225 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.12532 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01225 | 0.0125 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.12112 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0125 | 0.01275 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.11732 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01275 | 0.013 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.11373 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.013 | 0.01325 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.10962 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01325 | 0.0135 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.10705 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0135 | 0.01375 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.10622 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01375 | 0.014 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.10516 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.014 | 0.01425 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.10407 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01425 | 0.0145 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.10325 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0145 | 0.01475 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.10293 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01475 | 0.015 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.10317 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.015 | 0.015 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.0216366 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.015 | 0.01523 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.00204 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01523 | 0.01525 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.0863377 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01525 | 0.0155 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.14082 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0155 | 0.01575 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.15545 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01575 | 0.016 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.17017 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.016 | 0.01625 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.18519 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01625 | 0.02 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 19.9074 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.02 | 0.025 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 33.207 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.025 | 0.03 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 38.828 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.03 | 0.035 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 39.4743 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.035 | 0.04 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 39.66 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.04 | 0.045 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 42.1375 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.045 | 0.05 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 44.5359 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.05 | 0.055 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 46.4134 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.055 | 0.06 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 48.9108 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06 | 0.065 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 51.6215 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.065 | 0.06699 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 21.3035 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06699 | 0.06724 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.70019 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06724 | 0.06749 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.70667 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06749 | 0.06774 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.71306 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06774 | 0.06799 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.7195 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06799 | 0.06824 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.72589 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06824 | 0.06849 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.73225 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06849 | 0.06853 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.372272 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06853 | 0.06874 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.38323 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06874 | 0.06899 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.76403 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06899 | 0.06924 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.76983 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06924 | 0.06949 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.77528 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06949 | 0.06974 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.78122 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06974 | 0.06999 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.78729 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06999 | 0.07 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.0614085 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07 | 0.07024 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.73136 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07024 | 0.07049 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.79782 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07049 | 0.07074 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.80263 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07074 | 0.07099 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.80711 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07099 | 0.07124 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.81125 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07124 | 0.07149 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.81504 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07149 | 0.07174 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.81849 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07174 | 0.07199 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.82159 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07199 | 0.07224 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.82436 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07224 | 0.07249 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.82367 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07249 | 0.07274 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.819 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07274 | 0.07299 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.81351 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07299 | 0.07324 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.80773 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07324 | 0.07349 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.80169 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07349 | 0.07374 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.7954 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07374 | 0.07399 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.78889 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07399 | 0.07424 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.78218 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07424 | 0.07449 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.77528 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07449 | 0.07474 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.76823 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07474 | 0.07499 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.75993 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07499 | 0.075 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.0606371 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.075 | 0.07524 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.68977 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07524 | 0.07549 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.74027 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07549 | 0.07574 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.72962 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07574 | 0.07599 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.71873 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07599 | 0.07603 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.424255 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07603 | 0.07624 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.29186 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07624 | 0.07649 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.71537 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07649 | 0.07674 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.71678 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07674 | 0.0791 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 25.5011 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0791 | 0.08 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 9.68384 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12839 | 0.12935 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 11.7509 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12935 | 0.13 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 7.86495 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13 | 0.13172 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 20.2602 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13172 | 0.13197 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.91433 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13197 | 0.13222 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.92279 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13222 | 0.13247 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.93069 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13247 | 0.13272 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.93801 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13272 | 0.13297 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.94401 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13297 | 0.13322 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.9486 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13322 | 0.13347 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.95165 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13347 | 0.13372 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.95253 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13372 | 0.13397 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.94607 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13397 | 0.13422 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.93631 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13422 | 0.13447 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.92747 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13447 | 0.13472 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.9168 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13472 | 0.13497 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.90475 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13497 | 0.135 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.384795 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.135 | 0.13506 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.701691 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13506 | 0.13522 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.82166 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13522 | 0.13547 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.89864 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13547 | 0.13572 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.86806 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13572 | 0.13597 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.83412 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13597 | 0.13622 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.8007 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13622 | 0.13647 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.77898 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13647 | 0.13672 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.76277 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13672 | 0.13697 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.74154 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13697 | 0.13722 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.71564 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13722 | 0.13747 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.67998 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13747 | 0.13772 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.64922 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13772 | 0.13797 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.63421 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13797 | 0.13822 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.62518 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13822 | 0.13847 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.61804 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13847 | 0.13872 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.62571 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13872 | 0.13897 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.64636 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13897 | 0.13915 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.97581 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13915 | 0.13922 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.685804 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13922 | 0.13947 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.65188 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13947 | 0.13972 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.65727 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13972 | 0.13997 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.66481 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13997 | 0.14 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.354472 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14 | 0.14022 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.31731 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14022 | 0.14047 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.6737 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14047 | 0.14072 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.62886 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14072 | 0.14097 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.42112 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14097 | 0.14122 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.10235 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14122 | 0.14147 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.85042 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14147 | 0.14172 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.80608 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14172 | 0.14383 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 18.2062 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14383 | 0.14408 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.45804 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14408 | 0.14433 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.44226 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14433 | 0.14458 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.42661 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14458 | 0.14483 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.41109 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14483 | 0.145 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.65285 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.145 | 0.14508 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.741404 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14508 | 0.14533 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.37798 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14533 | 0.14558 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.3618 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14558 | 0.14583 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.34558 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14583 | 0.14608 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.3293 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14608 | 0.14633 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30957 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14633 | 0.14644 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.995615 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14644 | 0.14658 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.29486 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14658 | 0.14683 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.27545 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14683 | 0.14708 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.26147 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14708 | 0.14733 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.2475 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14733 | 0.14758 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.23349 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14758 | 0.14783 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.21946 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14783 | 0.14808 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.20507 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14808 | 0.14833 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.19035 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14833 | 0.14858 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.17582 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14858 | 0.14883 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.17387 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14883 | 0.14908 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.18124 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14908 | 0.14933 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.19021 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14933 | 0.14958 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.20306 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14958 | 0.14983 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.2146 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14983 | 0.15 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.53391 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15 | 0.15008 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.692244 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15008 | 0.15033 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.23684 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15033 | 0.15058 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.24866 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15058 | 0.15083 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.26148 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15083 | 0.15095 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.12886 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15095 | 0.15108 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.18209 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15108 | 0.15133 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.3666 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15133 | 0.15158 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.39006 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15158 | 0.15183 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.4135 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15183 | 0.15395 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 21.485 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0 | 0.15395 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 10.597 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0 | 0.0095 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 53.5124 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0095 | 0.00975 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.45675 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00975 | 0.01 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.44587 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01 | 0.01 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.0282078 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01 | 0.01025 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.40454 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01025 | 0.0105 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.4197 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0105 | 0.01075 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.40671 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01075 | 0.011 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.39458 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.011 | 0.01123 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.28588 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01123 | 0.01125 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.0975283 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01125 | 0.0115 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.36022 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0115 | 0.01175 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.3546 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01175 | 0.012 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.34949 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.012 | 0.01225 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.34485 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01225 | 0.0125 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.34065 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0125 | 0.01275 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.33685 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01275 | 0.013 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.33326 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.013 | 0.01325 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.32916 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01325 | 0.0135 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.32658 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0135 | 0.01375 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.32575 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01375 | 0.014 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.32469 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.014 | 0.01425 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.3236 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01425 | 0.0145 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.32278 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0145 | 0.01475 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.32246 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01475 | 0.015 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.3227 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.015 | 0.015 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.0259413 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.015 | 0.01523 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.20055 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01523 | 0.01525 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.103075 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01525 | 0.0155 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.36044 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0155 | 0.01575 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.37508 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01575 | 0.016 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.3898 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.016 | 0.01625 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.40482 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01625 | 0.02 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 23.2061 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.02 | 0.025 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 37.5995 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.025 | 0.03 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 43.2205 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.03 | 0.035 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 43.8668 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.035 | 0.04 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 44.0525 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.04 | 0.045 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 46.53 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.045 | 0.05 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 48.9284 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.05 | 0.055 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 50.8059 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.055 | 0.06 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 53.3033 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06 | 0.065 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 56.014 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.065 | 0.06699 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 23.0556 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06699 | 0.06724 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.91981 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06724 | 0.06749 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.92629 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06749 | 0.06774 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.93269 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06774 | 0.06799 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.93912 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06799 | 0.06824 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.94552 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06824 | 0.06849 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.95187 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06849 | 0.06853 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.402156 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06853 | 0.06874 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.57291 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06874 | 0.06899 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.98356 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06899 | 0.06924 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.98936 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06924 | 0.06949 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.99481 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06949 | 0.06974 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.00075 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06974 | 0.06999 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.00682 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06999 | 0.07 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.0662402 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07 | 0.07024 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.94607 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07024 | 0.07049 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.01735 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07049 | 0.07074 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.02216 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07074 | 0.07099 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.02664 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07099 | 0.07124 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.03078 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07124 | 0.07149 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.03458 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07149 | 0.07174 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.03802 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07174 | 0.07199 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.04113 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07199 | 0.07224 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.04389 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07224 | 0.07249 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.0432 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07249 | 0.07274 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.03853 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07274 | 0.07299 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.03304 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07299 | 0.07324 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.02726 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07324 | 0.07349 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.02122 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07349 | 0.07374 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.01493 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07374 | 0.07399 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.00842 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07399 | 0.07424 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.00171 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07424 | 0.07449 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.99482 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07449 | 0.07474 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.98777 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07474 | 0.07499 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.97946 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07499 | 0.075 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.0654689 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.075 | 0.07524 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.90448 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07524 | 0.07549 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.9598 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07549 | 0.07574 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.94915 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07574 | 0.07599 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.93825 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07599 | 0.07603 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.458593 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07603 | 0.07624 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.47715 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07624 | 0.07649 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.935 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07649 | 0.07674 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.93641 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07674 | 0.0791 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 27.5703 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0791 | 0.08 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 10.4746 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.08 | 0.08067 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 8.11215 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.08067 | 0.08425 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 43.7766 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.08425 | 0.085 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 8.9756 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.085 | 0.09 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 59.3615 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.09 | 0.095 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 59.674 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.095 | 0.1 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 60.6573 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1 | 0.1048 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 59.2911 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1048 | 0.105 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.49037 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.105 | 0.10982 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 60.7399 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12143 | 0.125 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 48.6683 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.125 | 0.12839 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 44.4283 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12839 | 0.12935 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 12.5905 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12935 | 0.13 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 8.43707 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13 | 0.13172 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 21.7684 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13172 | 0.13197 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.13396 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13197 | 0.13222 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.14242 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13222 | 0.13247 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.15031 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13247 | 0.13272 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.15764 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13272 | 0.13297 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.16364 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13297 | 0.13322 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.16822 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13322 | 0.13347 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.17127 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13347 | 0.13372 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.17216 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13372 | 0.13397 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.1657 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13397 | 0.13422 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.15593 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13422 | 0.13447 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.1471 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13447 | 0.13472 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.13642 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13472 | 0.13497 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.12437 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13497 | 0.135 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.413961 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.135 | 0.13506 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.754923 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13506 | 0.13522 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.95886 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13522 | 0.13547 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.11817 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13547 | 0.13572 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.08759 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13572 | 0.13597 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.05365 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13597 | 0.13622 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 3.02024 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13622 | 0.13647 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.99851 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13647 | 0.13672 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.9823 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13672 | 0.13697 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.96107 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13697 | 0.13722 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.93518 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13722 | 0.13747 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.89951 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13747 | 0.13772 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.86875 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13772 | 0.13797 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.85374 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13797 | 0.13822 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.84471 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13822 | 0.13847 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.83757 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13847 | 0.13872 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.84524 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13872 | 0.13897 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.86589 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13897 | 0.13915 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.13863 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13915 | 0.13922 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.742578 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13922 | 0.13947 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.87151 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13947 | 0.13972 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.87689 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13972 | 0.13997 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.88443 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13997 | 0.14 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.383638 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14 | 0.14022 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.50777 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14022 | 0.14047 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.89332 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14047 | 0.14072 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.84848 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14072 | 0.14097 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.64074 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14097 | 0.14122 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.32198 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14122 | 0.14147 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.07005 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14147 | 0.14172 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.0257 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14172 | 0.14383 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 20.0605 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14383 | 0.14408 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.67767 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14408 | 0.14433 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.66188 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14433 | 0.14458 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.64623 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14458 | 0.14483 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.63071 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14483 | 0.145 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.8043 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.145 | 0.14508 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.809575 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14508 | 0.14533 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.5976 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14533 | 0.14558 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.58143 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14558 | 0.14583 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.5652 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14583 | 0.14608 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.54893 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14608 | 0.14633 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.52919 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14633 | 0.14644 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.0909 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14644 | 0.14658 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.41918 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14658 | 0.14683 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.49498 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14683 | 0.14708 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.481 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14708 | 0.14733 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.46703 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14733 | 0.14758 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.45302 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14758 | 0.14783 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.43899 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14783 | 0.14808 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.4246 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14808 | 0.14833 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.40989 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14833 | 0.14858 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39535 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14858 | 0.14883 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39341 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14883 | 0.14908 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.40078 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14908 | 0.14933 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.40974 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14933 | 0.14958 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.42259 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14958 | 0.14983 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.43413 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14983 | 0.15 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.68534 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15 | 0.15008 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.760413 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15008 | 0.15033 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.45638 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15033 | 0.15058 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.46819 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15058 | 0.15083 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.48102 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15083 | 0.15095 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.23795 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15095 | 0.15108 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.29261 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15108 | 0.15133 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.58623 | řezová metoda
