Properties of the parts of a building model (IFC4), part 3 of 3

# IfcBuildingElementProxy (875)
Name | Označení stavebního objektu | Označení podobjektu = Označení části objektu = Klasifikační systém = Označení položky = Označení šablony vlastností = Stavební postup / etapa výstavby | Název stavebního objektu | Staničení od | Staničení do | Označení elementu | Skupina elementů | Klasifikace zemin / hornin = Třída těžitelnosti = Další specifikace | Datum zahájení prací | Datum dokončení | Doba trvání | Textura / barva | Objem | Způsob stanovení objemu
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12724 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.24376 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12749 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.34838 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12774 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.2983 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12799 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.38329 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12824 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.36146 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12849 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.21647 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12874 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.37083 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12899 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.56676 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12903 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.404664 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12649 | 0.13 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 9.93882 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13 | 0.135 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 49.4295 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.135 | 0.14 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 43.3014 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14 | 0.14385 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 26.6642 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14385 | 0.1441 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.49931 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1441 | 0.14428 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.1123 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14428 | 0.14435 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.364673 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14435 | 0.1446 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.44882 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1446 | 0.14485 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.44001 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14485 | 0.145 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.885833 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.145 | 0.1451 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.558225 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1451 | 0.14535 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.4477 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14535 | 0.1456 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.46776 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1456 | 0.14585 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.50288 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14585 | 0.1461 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.53747 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1461 | 0.14635 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.57239 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14635 | 0.14638 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.223254 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14638 | 0.1466 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.4122 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1466 | 0.14844 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 13.5833 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06071 | 0.06094 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0147216 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06096 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0013984 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06096 | 0.06121 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06121 | 0.06146 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06146 | 0.06171 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06171 | 0.06196 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06196 | 0.06221 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06221 | 0.06246 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06346 | 0.06371 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06371 | 0.06396 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06396 | 0.06421 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06421 | 0.06446 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06446 | 0.06471 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06471 | 0.06496 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06496 | 0.065 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00279189 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.065 | 0.06521 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0133175 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06521 | 0.06544 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.014903 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06544 | 0.06546 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00120226 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06546 | 0.06571 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.01612 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06571 | 0.06661 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0580407 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12238 | 0.12263 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.01612 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12263 | 0.12288 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.01612 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39031 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39414 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39512 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0 | 0.14844 | obsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;165;0 | 20.67 | řezová metoda | CZ_S2 - Typ stavebního výrobku: Písek; Stavební výrobek: Písek; Specifikace: N/A; Podrobná specifikace: N/A; Reference: N/A; Výrobce: N/A; Kategorie stavebního výrobku: N/A; CZ_M6 - Tloušťka: 0
 |  |  |  | 0.00126 | 0.12799 | potrubí | trubní vedení |  | 29.04.2025 | 29.04.2025 | 0 | 0;255;255 | CZ_M1 - Délka: 126.73; Způsob stanovení délky: Délka 3D křivky
 |  |  |  | 0.06661 | 0.115 | potrubí | trubní vedení |  | 29.04.2025 | 29.04.2025 | 0 | 0;255;255 | CZ_M1 - Délka: 48.39; Způsob stanovení délky: Délka 3D křivky
 |  |  |  | 0.06661 | 0.115 | chránička | trubní vedení |  | 29.04.2025 | 29.04.2025 | 0 | 127;0;127 | CZ_M1 - Délka: 48.39; Způsob stanovení délky: Délka 3D křivky
 |  |  |  | 0.05283 | 0.1467 | potrubí | trubní vedení |  | 29.04.2025 | 29.04.2025 | 0 | 0;255;255 | CZ_M1 - Délka: 93.87; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1146 | 0.11499 | chránička | trubní vedení |  | 01.05.2026 | 30.11.2026 | 213 | 127;0;127 | CZ_M1 - Délka: 0.39; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0666 | 0.06779 | chránička | trubní vedení |  | 01.05.2026 | 30.11.2026 | 213 | 127;0;127 | CZ_M1 - Délka: 1.19; Způsob stanovení délky: Délka 3D křivky
