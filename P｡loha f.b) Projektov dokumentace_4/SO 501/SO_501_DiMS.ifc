Properties of the parts of a building model (IFC4), part 2 of 3

# IfcBuildingElementProxy (875)
Name | Označení stavebního objektu | Označení podobjektu = Označení části objektu = Klasifikační systém = Označení položky = Označení šablony vlastností = Stavební postup / etapa výstavby | Název stavebního objektu | Staničení od | Staničení do | Označení elementu | Skupina elementů | Klasifikace zemin / hornin = Třída těžitelnosti = Další specifikace | Datum zahájení prací | Datum dokončení | Doba trvání | Textura / barva | Objem | Způsob stanovení objemu
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15133 | 0.15158 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.60968 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15158 | 0.15183 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.63312 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.15183 | 0.15395 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 23.3485 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0 | 0.15395 | obsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;165;0 | 60.7345 | řezová metoda | CZ_S2 - Typ stavebního výrobku: Písek; Stavební výrobek: Písek; Specifikace: N/A; Podrobná specifikace: N/A; Reference: N/A; Výrobce: N/A; Kategorie stavebního výrobku: N/A; CZ_M6 - Tloušťka: 0
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00486 | 0.07664 | potrubí | trubní vedení | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;255;255 | CZ_M1 - Délka: 71.78; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07675 | 0.13172 | potrubí | trubní vedení | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;255;255 | CZ_M1 - Délka: 54.97; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13177 | 0.15102 | potrubí | trubní vedení | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;255;255 | CZ_M1 - Délka: 19.25; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0791 | 0.12839 | chránička | trubní vedení | N/A | 01.05.2026 | 30.11.2026 | 180 | 127;0;127 | CZ_M1 - Délka: 49.29; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.08103 | 0.08105 | Čichačka | Trubní vedení | N/A | 01.05.2026 | 30.11.2026 | 213 | 127;0;127 | CZ_M1 - Délka: 0.02; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12788 | 0.1279 | Čichačka | Trubní vedení | N/A | 01.05.2026 | 30.11.2026 | 213 | 127;0;127 | CZ_M1 - Délka: 0.02; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12799 | 0.1284 | Čichačka | Trubní vedení | N/A | 01.05.2026 | 30.11.2026 | 213 | 127;0;127 | CZ_M1 - Délka: 0.41; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07909 | 0.08123 | Čichačka | Trubní vedení | N/A | 01.05.2026 | 30.11.2026 | 213 | 127;0;127 | CZ_M1 - Délka: 2.14; Způsob stanovení délky: Délka 3D křivky
 | SO 501 | N/A | Přeložky VTL plynovodů | 0 | 0.00135 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 5.39069 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00135 | 0.0016 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.990501 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0016 | 0.00185 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.98918 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00185 | 0.002 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.592127 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.002 | 0.0021 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.392564 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0021 | 0.00235 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.978558 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00235 | 0.0026 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.977813 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0026 | 0.00285 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.979405 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00285 | 0.0031 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.986862 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0031 | 0.00335 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.996964 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00335 | 0.0036 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.00807 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0036 | 0.00385 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.01813 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00385 | 0.0041 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.0263 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0041 | 0.00435 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.03267 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00435 | 0.0046 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.03767 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0046 | 0.00479 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.811874 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00479 | 0.005 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.864163 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.005 | 0.01 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 21.5873 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01 | 0.015 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 26.2678 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.015 | 0.02 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 33.6679 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.02 | 0.025 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 39.7461 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.025 | 0.03 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 39.8235 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.03 | 0.035 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 37.2087 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.035 | 0.04 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 38.1732 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.04 | 0.045 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 40.0448 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.045 | 0.05 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 41.9485 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.05 | 0.055 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 43.8988 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.055 | 0.06 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 45.0829 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06 | 0.06071 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 6.41614 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06071 | 0.06547 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.07622 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.199483 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.29884 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30205 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30441 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30588 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30658 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30696 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30685 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30637 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06321 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30539 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06346 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.30186 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06371 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.29597 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06396 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.29018 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06421 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.28451 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06446 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.27884 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06471 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.27312 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06496 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.26813 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.065 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.392852 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06521 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.87234 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06544 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.09231 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06086 | 0.06546 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.168711 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06086 | 0.06571 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.26008 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06571 | 0.06661 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 8.10538 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06661 | 0.07 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 33.5317 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07 | 0.07086 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 9.20773 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07086 | 0.07422 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 35.5201 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07422 | 0.075 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 8.16231 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.075 | 0.08 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 52.7833 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.08 | 0.085 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 53.571 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.085 | 0.09 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 55.0292 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.09 | 0.09141 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 15.6675 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.09141 | 0.095 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 38.9745 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.095 | 0.09643 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 15.2942 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.10803 | 0.11 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 24.6104 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11 | 0.115 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 54.9967 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.115 | 0.11719 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 21.7112 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11719 | 0.11788 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 6.77307 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11788 | 0.12244 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.43373 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11813 | 0.12246 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.19319 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.24779 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.44891 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.44898 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.44409 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.42762 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.39884 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.36648 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.09833 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.24075 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12038 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.3084 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12063 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.28098 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12088 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.25512 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11823 | 0.12113 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.2434 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11825 | 0.12138 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.24458 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11825 | 0.12163 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.25426 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11825 | 0.12188 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.27609 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11825 | 0.12213 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.2958 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.38708 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11808 | 0.12238 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.921341 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.1181 | 0.12263 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.3185 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12263 | 0.12288 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.33228 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12288 | 0.125 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 19.7197 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.125 | 0.12649 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 13.6226 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12649 | 0.12923 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.24767 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12674 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.97892 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12699 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.18571 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12724 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.15553 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12918 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.14918 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12774 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.21004 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12799 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.26933 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12653 | 0.12826 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.20125 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12652 | 0.12849 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.9697 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12874 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.28258 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12899 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 2.4785 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12903 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.390768 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12649 | 0.13 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 9.59669 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13 | 0.135 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 47.6623 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.135 | 0.14 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 41.5342 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14 | 0.14385 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 25.3047 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14385 | 0.1441 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.41095 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1441 | 0.14428 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.04595 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14428 | 0.14435 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.342665 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14435 | 0.1446 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.36158 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1446 | 0.14485 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.35175 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14485 | 0.145 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.831603 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.145 | 0.1451 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.524123 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1451 | 0.14535 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.35944 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14535 | 0.1456 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.3795 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1456 | 0.14585 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.41462 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14585 | 0.1461 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.44921 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1461 | 0.14635 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.48413 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14635 | 0.14638 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 0.21088 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14638 | 0.1466 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 1.33622 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1466 | 0.14844 | zásyp rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | 180 | 0;128;0 | 12.9324 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0 | 0.00135 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0869319 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00135 | 0.0016 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.01612 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0016 | 0.00185 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.01612 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00185 | 0.002 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00965606 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.002 | 0.0021 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00646274 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0021 | 0.00235 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00235 | 0.0026 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0026 | 0.00285 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00285 | 0.0031 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0031 | 0.00335 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00335 | 0.0036 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0036 | 0.00385 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00385 | 0.0041 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0041 | 0.00435 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00435 | 0.0046 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0046 | 0.00479 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0125575 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00479 | 0.005 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0133418 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.005 | 0.01 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01 | 0.015 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.015 | 0.02 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.02 | 0.025 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.025 | 0.03 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.03 | 0.035 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.035 | 0.04 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.04 | 0.045 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.05 | 0.055 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.055 | 0.06 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06 | 0.06071 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.045568 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06246 | 0.06271 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06271 | 0.06296 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06296 | 0.06321 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06321 | 0.06346 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.115 | 0.11719 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.141141 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11719 | 0.11788 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0447551 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11788 | 0.11813 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.01612 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11813 | 0.11826 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0079111 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.11838 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00820643 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11838 | 0.11863 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11863 | 0.11888 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11888 | 0.11913 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11913 | 0.11938 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11938 | 0.11963 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11963 | 0.11988 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11988 | 0.12 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00754225 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12 | 0.12013 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00857303 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12013 | 0.12038 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12038 | 0.12063 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12063 | 0.12088 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12088 | 0.12113 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12113 | 0.12138 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12138 | 0.12163 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12163 | 0.12188 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12188 | 0.12213 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12213 | 0.12228 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00969102 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12228 | 0.12238 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00642493 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12288 | 0.125 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.136504 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.125 | 0.12649 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0962493 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12649 | 0.12663 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00897555 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12674 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00714283 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12674 | 0.12699 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12699 | 0.12724 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12724 | 0.12749 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12749 | 0.12774 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12774 | 0.12799 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12799 | 0.12824 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12824 | 0.12849 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12849 | 0.12874 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12874 | 0.12899 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12899 | 0.12903 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00253521 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.12903 | 0.13 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0624154 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.13 | 0.135 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.135 | 0.14 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.3224 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14 | 0.14385 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.248022 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14385 | 0.1441 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.01612 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1441 | 0.14428 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0121046 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14428 | 0.14435 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00401515 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14435 | 0.1446 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1446 | 0.14485 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14485 | 0.145 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00989336 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.145 | 0.1451 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00622125 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1451 | 0.14535 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14535 | 0.1456 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1456 | 0.14585 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14585 | 0.1461 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1461 | 0.14635 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0161013 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14635 | 0.14638 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.00225753 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.14638 | 0.1466 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.0138624 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.1466 | 0.14844 | podsyp | trubní vedení |  | 01.05.2026 | 30.11.2026 | 180 | 255;255;0 | 0.118744 | řezová metoda | CZ_S1 - Materiál: Písek; specifikace: Písek; podrobná specifikace: N/A; Reference: N/A
 | SO 501 | N/A | Přeložky VTL plynovodů | 0 | 0.00135 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 5.86721 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00135 | 0.0016 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.07886 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0016 | 0.00185 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.07754 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00185 | 0.002 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.645056 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.002 | 0.0021 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.427989 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0021 | 0.00235 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.06682 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00235 | 0.0026 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.06607 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0026 | 0.00285 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.06766 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00285 | 0.0031 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.07512 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0031 | 0.00335 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.08522 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00335 | 0.0036 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.09633 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0036 | 0.00385 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.10638 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00385 | 0.0041 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.11456 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0041 | 0.00435 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.12093 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00435 | 0.0046 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.12593 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.0046 | 0.00479 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.880707 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.00479 | 0.005 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.937295 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.005 | 0.01 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 23.3545 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.01 | 0.015 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 28.035 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.015 | 0.02 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 35.4351 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.02 | 0.025 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 41.5133 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.025 | 0.03 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 41.5907 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.03 | 0.035 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 38.976 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.035 | 0.04 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 39.9405 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.04 | 0.045 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 41.812 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.045 | 0.05 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 43.7157 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.05 | 0.055 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 45.666 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.055 | 0.06 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 46.8501 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06 | 0.06071 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 6.66591 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06071 | 0.06547 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.15692 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.207148 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.3871 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39267 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39492 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39524 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06094 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39463 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06321 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39365 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06346 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39016 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06371 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.38425 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06396 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.37846 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06421 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.37281 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06446 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.36711 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06471 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.3614 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06496 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.35641 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.065 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.408156 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06521 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.94534 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06093 | 0.06544 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.174 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06086 | 0.06546 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.175302 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06086 | 0.06571 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.34844 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06571 | 0.06661 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 8.42352 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.06661 | 0.07 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 34.2086 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07 | 0.07086 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 9.20773 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07086 | 0.07422 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 35.5201 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.07422 | 0.075 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 8.16231 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.075 | 0.08 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 52.7833 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.08 | 0.085 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 53.571 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.085 | 0.09 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 55.0292 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.09 | 0.09141 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 15.6675 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.09141 | 0.095 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 38.9745 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.095 | 0.09643 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 15.2942 | řezová metoda
 | SO 501 | N/A | Přeložky VTL plynovodů | 0.10803 | 0.11 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 24.6104 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11 | 0.115 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 55.9941 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.115 | 0.11719 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 22.4849 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11719 | 0.11788 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 7.0184 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11788 | 0.12244 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.52209 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11813 | 0.12246 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.23655 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.29278 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.53718 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.53724 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.53235 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.51587 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.4871 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.45481 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.13971 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.28772 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12038 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.39674 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12063 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.36926 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12088 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.34341 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11823 | 0.12113 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.33166 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11825 | 0.12138 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.33283 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11825 | 0.12163 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.34249 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11825 | 0.12188 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.36431 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11825 | 0.12213 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.38408 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11826 | 0.12228 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.44019 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.11808 | 0.12238 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 0.956558 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.1181 | 0.12263 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.40686 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12263 | 0.12288 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.42064 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12288 | 0.125 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 20.4679 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.125 | 0.12649 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 14.1502 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12649 | 0.12923 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.29687 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12674 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 1.01808 | řezová metoda
2 x  | SO 501 | N/A | Přeložky VTL plynovodů | 0.12663 | 0.12699 | výkop rýhy | zemní práce | N/A | 01.05.2026 | 30.11.2026 | N/A | 125;75;0 | 2.27401 | řezová metoda
